# IAR project audio.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32E103xB GD GD32E103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E10X; USE_USB_FS; USE_USB_AUDIO_SPEAKER; GD32E103V_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32E10x\Include; ..\..\..\..\..\Firmware\GD32E10x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\device\class\audio\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Audio.srec
  ILINK.IlinkOutputFile: audio.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appliaction
    ../src/: app.c gd32e10x_hw.c gd32e10x_it.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Doc
    ../: readme.txt
  group GD32E10x_EVAL
    ../src/: gd32e103v_audio_codec.c
    ../../../../../Utilities/: gd32e10x_eval.c
  group GD32E10x_StdPeriph
    ../../../../../Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_ctc.c gd32e10x_dma.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/IAR/: startup_gd32e10x.s
  group USB_Class
    ../../../../../Firmware/GD32E10x_usbfs_library/device/class/audio/Source/: audio_core.c audio_out_itf.c
  group USB_Device
    ../../../../../Firmware/GD32E10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32E10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
